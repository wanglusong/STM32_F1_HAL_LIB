# Keil uVision project 阿松工作室.uvprojx, settings and files
target COMPONENTS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ech +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --diag_suppress=111 --diag_suppress=174 --locale=english
  c include: ..\AUDIO\TEA5767;..\FS\FATFS\exfuns;..\FS\FATFS\src;..\FS\FATFS\doc;..\FS\SD;..\FS\W25QXX;..\KERNEL\CORE;..\KERNEL\HALLIB\STM32F1xx_HAL_Driver\Inc;..\KERNEL\MALLOC;..\KERNEL\SYS;.\OBJ;..\PRO;..\..\LittleVGL;..\..\LittleVGL\lv_port;..\..\LittleVGL\lvgl;..\KERNEL\FREERTOS\include;..\KERNEL\FREERTOS\portable\RVDS\ARM_CM3;..\DRIVE\ECH_ADC;..\DRIVE\ECH_DELAY;..\DRIVE\ECH_KEY;..\DRIVE\ECH_LED;..\DRIVE\ECH_SPI;..\DRIVE\ECH_TIM;..\DRIVE\ECH_UART;..\ECH\gui\lv_apps\lv_ech_idle;..\ECH\gui\lv_apps\lv_ech_base_souce;..\ECH\gui\lv_drivers\ECH_OLED;..\ECH\gui\lv_drivers\ECH_ST7735;..\ECH\gui\lv_drivers\ECH_ST7789;..\ECH\gui\lv_drivers\ECH_TFT;..\ECH\gui\lv_include;..\ECH\gui\lv_objx\lv_ech_list;..\ECH\gui\lv_objx\lv_ech_obj;..\ECH\gui\lv_objx\lv_ech_win;..\ECH\gui\resource\image\base_bg;..\ECH\gui\resource\image\battery;..\ECH\gui\lv_drivers;..\ECH\gui\resource\font
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group AUDIO
    ../AUDIO/TEA5767/: TEA5767.c
  group DRIVE
    ../DRIVE/ECH_ADC/: ech_adc.c
    ../DRIVE/ECH_DELAY/: ech_delay.c
    ../DRIVE/ECH_KEY/: ech_key.c
    ../DRIVE/ECH_LED/: ech_led.c
    ../DRIVE/ECH_SPI/: ech_spi.c
    ../DRIVE/ECH_TIM/: ech_tim.c
    ../DRIVE/ECH_UART/: ech_uartall.c
  group FS
    ../FS/W25QXX/: w25qxx.c
    ../FS/SD/: MMC_SD.C
  group KERNEL
    ./: system_stm32f1xx.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../KERNEL/CORE/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm3.h startup_stm32f103xe.s
    ../KERNEL/HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c
    ../KERNEL/SYS/: sys.c
  group KERNEL/FreeRTOS_CORE
    ../KERNEL/FREERTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group KERNEL/FreeRTOS_PORTABLE
    ../KERNEL/FREERTOS/portable/MemMang/: heap_4.c
    ../KERNEL/FREERTOS/portable/RVDS/ARM_CM3/: port.c
  group ECH/gui/lv_apps
    ../ECH/gui/lv_apps/lv_ech_idle/: lv_ech_idle.c
    ../ECH/gui/lv_apps/lv_ech_base_souce/: lv_ech_base_souce.c
  group ECH/gui/lv_drivers
    ../ECH/gui/lv_drivers/ECH_OLED/: ech_oled_iic.c
    ../ECH/gui/lv_drivers/ECH_ST7735/: ech_st7735_spi.c
    ../ECH/gui/lv_drivers/ECH_ST7789/: ech_st7789_spi.c
    ../ECH/gui/lv_drivers/ECH_TFT/: ech_tft.c
  group ECH/gui/lv_external
    ../ECH/gui/lv_external/: lv_ech_lib.c
  group ECH/gui/lv_objx
    ../ECH/gui/lv_objx/lv_ech_list/: lv_ech_list.c
    ../ECH/gui/lv_objx/lv_ech_obj/: lv_ech_obj.c
    ../ECH/gui/lv_objx/lv_ech_win/: lv_ech_win.c
  group ECH/gui/resource/font
    ../ECH/gui/resource/font/: lv_poc_font_msyh_1bit_2500_12.c lv_poc_font_msyh_1bit_2500_13.c lv_poc_font_msyh_1bit_2500_14.c lv_poc_font_msyh_1bit_2500_15.c lv_poc_font_msyh_1bit_2500_16.c lv_poc_font_msyh_1bit_2500_18.c
  group ECH/gui/resource/img
    ../ECH/gui/resource/image/base_bg/: img_cogwheel_rgb.c ic_launcher_bg.c
    ../ECH/gui/resource/image/battery/: stat_sys_battery_0.c stat_sys_battery_15.c stat_sys_battery_28.c stat_sys_battery_43.c stat_sys_battery_57.c stat_sys_battery_71.c stat_sys_battery_85.c stat_sys_battery_100.c stat_sys_battery_charge_anim0.c stat_sys_battery_charge_anim15.c stat_sys_battery_charge_anim28.c stat_sys_battery_charge_anim43.c stat_sys_battery_charge_anim57.c stat_sys_battery_charge_anim71.c stat_sys_battery_charge_anim85.c stat_sys_battery_charge_anim100.c stat_sys_no_battery.c
  group NET
    ../NET/ECH_ESP8266/: ech_esp8266_uart.c
  group PRO
    ./: appstart.c
  group LV_DISPLAY
    ../../LittleVGL/lv_port/: lv_gui_main.c lv_port_disp.c
  group LV_CORE
    ../../LittleVGL/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group LV_DRAW
    ../../LittleVGL/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group LV_HAL
    ../../LittleVGL/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LV_MISC
    ../../LittleVGL/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LV_THEMES
    ../../LittleVGL/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
  group LV_FONT
    ../../LittleVGL/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_montserrat_14.c
  group LV_OBJX
    ../../LittleVGL/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group README
    ../: readme.txt
